Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-11-27T09:40:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Fri Nov 27 09:40:58 2020* Host: BIMServices* Database: C:\Users\PIOTRB~1\AppData\Local\Temp\{5B74ACA3-68A9-42ED-B34C-70B41CFCA093}\ifc* Database version: 5507* Database creation date: Fri Nov 27 09:40:57 2020* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Fri Nov 27 09:40:57 2020* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Fri Nov 27 09:40:57 2020* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcDistributionPort, Port_364652
Description: Flow; FlowDirection: SINK

# IfcFlowTerminal: SUBWAY 2.0_WCComplete_5614R2, NBS_VilleroyAndBoch_WCPns_SUBWAY2_WCComplete_5614R2:SUBWAY 2.0_WCComplete_5614R2:364652
In: Level 0
Type - PredefinedType: TOILETPAN; Classification: Pr_40_20_93_94 (Uniclass2015); Material: NBS_Concept
Type - BOS_General - Author: NBS; BIMObjectName: NBS_VilleroyAndBoch_WcPans_SUBWAY2.0_WCComplete_5614R2; ManufacturerName: Villeroy & Boch; ManufacturerURL: https://pro.villeroy-boch.com/en/gb/home.html; NBSCertification: www.nationalbimlibrary.com/cert/jfn2os11; NBSDescription: WC pans; NBSReference: 45-35-70/384; ProductInformation: https://www.villeroy-boch.co.uk/bathroom-and-wellness/products/Subway-2.0-Combi-Pack-Oval-5614R2.html; Revision: n/a; Uniclass2015Title: WC pans; Uniclass2015Code: Pr_40_20_93_94; Uniclass2015Version: Products v1.17; Version: 2
Type - NBS_Data - Weight: 25.6 kg; FlushVolume: 3 / 4,5 l; Installation: Wall-mounted; Outlet: Horizontal outlet; Leed: 4
Type - Pset_SanitaryTerminalTypeCommon - NominalLength: 0 mm; Color: White alpin; NominalDepth: 560 mm; NominalWidth: 370 mm; Reference: n/a
Type - IFC - IfcExportAs: IfcSanitaryTerminalType; IfcExportType: TOILETPAN
Type - COBie - NominalHeight: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_20_93_94:WC pans; CodePerformance: EN 997; Constituents: n/a; Description: Complete combi pack WC; DurationUnit: year; ExpectedLife: n/a; Features: Slimseat, quick release, soft closing hinges, no visible screws, quick and easy to clean, long lasting, duel flush; Finish: n/a; Grade: n/a; Manufacturer: marketing@villeroy-boch.co.uk; Material: Sanitary ceramics; ModelNumber: 5614R2; ModelReference: SUBWAY 2.0_WCComplete_5614R2; Name: WcPans_SUBWAY2.0_WCComplete_5614R2_VilleroyAndBoch; ReplacementCost: n/a; Shape: n/a; Size: 370 x 360 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
BOS_General - Version: 1
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
